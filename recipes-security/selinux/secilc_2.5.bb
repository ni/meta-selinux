include selinux_20160223.inc
include ${BPN}.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5fb82e8deb357d4e5fd8f3fed01d2f38"

SRC_URI[md5sum] = "af73267cccd0e46cb455d5702565cd41"
SRC_URI[sha256sum] = "4303d911c06ee5c207e00f778ca786c1a6efa2554a562f5d014dbc0d2f4cc4a4"
