require selinux_20190315.inc
require ${BPN}.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=5fb82e8deb357d4e5fd8f3fed01d2f38"

SRC_URI[md5sum] = "489cedf50fa277ce07765053ffcdb4d5"
SRC_URI[sha256sum] = "73a1806e33a669e23545da2d35d0e5038714721f6bf71974eaa533b3ebde61b2"
