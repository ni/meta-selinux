include selinux_20160223.inc
include ${BPN}.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"

SRC_URI[md5sum] = "d17b4072ed14d1f8d94ffd667ddc2864"
SRC_URI[sha256sum] = "3ee1745257fa55301070219c77978c7c9eeb9aa595ce0b6b29c3baa4687d5cf0"
