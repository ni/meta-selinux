include selinux_20160223.inc
include ${BPN}.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"

SRC_URI[md5sum] = "a8099a2a36de32327abf681159027c58"
SRC_URI[sha256sum] = "33af9f3eb19135a7e6536ecd3fbb9686323000016cd51eb88346346ed7546001"