PR = "r0"

include selinux_20120924.inc
include ${BPN}.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"

SRC_URI[md5sum] = "d734ff236639cc1bd3a33901774fa98d"
SRC_URI[sha256sum] = "b5f56130619672b782658c0c9e32d621a1dcaaa6f7d3cffc10f47c4e5a625aeb"
